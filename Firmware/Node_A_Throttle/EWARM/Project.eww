<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Node_A_Throttle.ewp</path>
  </project>
  <batchBuild />
</workspace>
